## boards/shields/bard/Kconfig.defconfig
```kconfig
if SHIELD_BARD

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "bard"

endif
```
